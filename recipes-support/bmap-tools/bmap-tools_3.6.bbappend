# meta-poly-tc8/recipes-support/bmap-tools/bmap-tools_3.6.bbappend
SRC_URI = "git://github.com/intel/bmap-tools.git;protocol=https;branch=main"
SRCREV = "7106093031ee7211a6e4dab8a7ca1b76e0940b0b"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b234ee4d69f5fce4486a80fdaf4a4263"
PE = "1"
